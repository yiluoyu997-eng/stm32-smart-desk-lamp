# Keil uVision project Project.uvprojx, settings and files
target SmartLamp-F411RE (6070000::V6.7::.\ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: SmartLamp-F411RE +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F411xE,USE_STM32F4XX_NUCLEO
  c include: ..\Inc;..\..\Core\Inc;..\..\..\.tools\STM32CubeF4\Drivers\CMSIS\Include;..\..\..\.tools\STM32CubeF4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\.tools\STM32CubeF4\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\.tools\STM32CubeF4\Drivers\BSP\STM32F4xx-Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../.tools/STM32CubeF4/Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../../../.tools/STM32CubeF4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_flash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_uart.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2s.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_can.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_adc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_hash.c stm32f4xx_hal_hcd.c stm32f4xx_hal_irda.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma.c stm32f4xx_hal_crc.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_tim.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_gpio.c stm32f4xx_ll_fsmc.c
  group Example/MDK-ARM
    ./: startup_stm32f411xe.s
  group Example/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group SmartLamp/Core
    ../../Core/Src/: lamp_core.c
software components: CMSIS:CORE 5.3.0
